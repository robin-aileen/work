# Keil uVision project project.uvprojx, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\User\bsp;..\..\User\bsp\inc;..\..\User;..\..\Libraries\CMSIS\Include;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM3;..\..\User\app;..\..\User\lcd\inc;..\..\User\hx711;..\..\User\delay
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../../User/: main.c includes.h FreeRTOSConfig.h
  group App
    ../../User/app/: bsp_motor.c bsp_uart_lcd.c filter.c debug.c save2flash.c eeprom.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32f10x_it.c stm32f10x_assert.c
    ../../User/bsp/src/: bsp_key.c bsp_led.c bsp_uart_fifo.c bsp_beep.c bsp_simple_timer.c bsp_adc_int.c bsp_dwt.c bsp_ble.c
  group LCD
    ../../User/lcd/src/: cmd_queue.c hmi_driver.c hmi_user_uart.c ulitity.c hw_config.c
  group Hx711
    ../../User/hx711/: HX711.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_tim.c stm32f10x_adc.c
  group CMSIS
    ../../User/bsp/: system_stm32f10x.c
  group FreeRTOS/Source
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Ports
    ../../FreeRTOS/portable/RVDS/ARM_CM3/: port.c portmacro.h
    ../../FreeRTOS/portable/MemMang/: heap_4.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt 03.开发环境说明.txt
software components: CMSIS:CORE 5.1.2
